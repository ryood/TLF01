# Repository ryood/TLF01

## EAGLE design TLF01_Antilog/Antilog_NPNO/eagle/Antilog-NPNO/Antilog-NPNO.brd

Parts:
C1, C2: 47u; E2,5-6
C3: 100p; C050-024X044
C4, C5: 0.1u; C025-024X044
CN1: PWRIN; B3B-XH-A
IC1: NJM4580; DIL08
JP1: CUTOFF; 1X03
JP2: MOD1; 1X02
JP3: MOD2; 1X02
JP4: OUT; 1X02
JP5: TP_GND; 1X02
JP6: TP_+12V; 1X01
LED1: RED; LED3MM
LED2: BLUE; LED3MM
R1: 100k; 0207/7
R2, R3, R8, R15, R16: 10k; 0207/7
R4, R5: 47k; 0207/7
R6: 2k; 0207/7
R10: 20k; 0207/7
R11, R12, R14: 1k; 0207/7
R13: 68k; 0207/7
T1, T2: 2SC1815; TO92-ECB

Connections:
+12V: C1.+, C4.1, CN1.1, IC1.8 (V+), JP6.1, R2.2, R13.2, R15.2
-12V: C2.-, C5.2, CN1.3, IC1.4 (V-), R3.1, R16.1
GND: C1.-, C2.+, C4.2, C5.1, CN1.2, IC1.3 (+IN), IC1.5 (+IN), JP2.2, JP3.2, JP4.2, JP5.1, JP5.2, LED1.K (C), LED2.A, R11.1, T2.B
unnamed: JP3.1, R5.1
unnamed: R10.1, R11.2, T1.B
unnamed: JP1.2, R1.1
unnamed: JP2.1, R4.1
unnamed: IC1.1 (OUT), R6.2, R8.2
unnamed: R6.1, R10.2
unnamed: JP1.1, R2.1
unnamed: JP1.3, R3.2
unnamed: IC1.2 (-IN), R1.2, R4.2, R5.2, R8.1
unnamed: R14.1, T2.C
unnamed: LED1.A, R15.1
unnamed: JP4.1, R14.2
unnamed: R12.2, T1.E, T2.E
unnamed: C3.2, IC1.7 (OUT), R12.1
unnamed: C3.1, IC1.6 (-IN), R13.1, T1.C
unnamed: LED2.K (C), R16.2

Notes on the sheet:
10k POT
0~5V
R1~R5はピンソケットで実装
R6,R10はピンソケットで実装
R13はピンソケットで実装

Board: 2 copper layers, 71.1 x 45.7 mm, 31 parts (0 on the bottom side), 19 nets.

## EAGLE design TLF01_Antilog/eagle/TLF01_Antilog_MM/AntilogMM.brd

Parts:
C1, C2: 22uF; E2,5-6
C3: 100pF; C050-024X044
JP1: MOD1; 1X02
JP2: MOD2; 1X02
JP3: CutOff; 1X03
JP4: OUT; 1X02
JP5: TP_GND; 1X02
JP6: EXTPWR; 1X03
LED1: RED; LED3MM
LED2: GREEN; LED3MM
P1: PWRIN; B3B-EH-A
R1, R2, R3: 47k; 0207/7
R4: 2.2k; 0207/7
R5: 68k; 0207/7
R6: 10k; B25P
R7: 330; 0207/7
R8: 680; 0207/7
R9, R10: 1k; 0207/7
T1: 2SA1015; TO92-ECB
T2: 2SC1815; TO92-ECB

Connections:
+9V: C1.+, JP3.1, JP6.1, P1.1, R6.E, R9.2
-9V: C2.-, JP3.3, JP6.3, P1.3, R7.1, R10.1
GND: C1.-, C2.+, C3.2, JP1.2, JP2.2, JP4.2, JP5.1, JP5.2, JP6.2, LED1.K (C), LED2.A, P1.2, R4.1, R6.A, T2.E
unnamed: R8.1, T2.C
unnamed: R7.2, T1.C
unnamed: LED2.K (C), R10.2
unnamed: JP4.1, R8.2
unnamed: LED1.A, R9.1
unnamed: R5.2, R6.S
unnamed: R5.1, T1.E, T2.B
unnamed: C3.1, R1.2, R2.2, R3.2, R4.2, T1.B
unnamed: JP1.1, R1.1
unnamed: JP2.1, R2.1
unnamed: JP3.2, R3.1

Notes on the sheet:
R4はピンソケットで実装
R3はピンソケットで実装

Board: 2 copper layers, 45.7 x 70.8 mm, 24 parts (0 on the bottom side), 14 nets.

## EAGLE design eagle/TLF01/TLF01.brd

Parts:
C1: 10uF; E2,5-6
C2: 220uF; E5-8,5
C3, C4, C5, C6: 0.068uF; C075-052X106
C7: 10uF/BP; E5-8,5
C8, C9: 100uF; E2,5-7
C10, C11: 0.1uF; C025-025X050
IC1: TL072P; DIL08
J1: 2SK170; TO-92
JP1, JP9: WaveIn; 1X02
JP2: TP_GND; 1X02
JP3: Resonance; 1X02
JP4, JP10: FilterOut; 1X02
JP5, JP11: PWR; B3B-EH-A
JP6: Ictrl; 1X02
JP7: IctrlExt; 1X02
JP8: IctlSelect; 1X03
LED1: Red; LED3MM
LED2: Green; LED3MM
R1, R2, R9, R10, R15, R16, R17, R18: 1k; 0207/7
R3: 220; 0207/7
R4, R5, R6, R7: 150; 0207/7
R8: 200; 0207/7
R11, R13: 100k; 0207/7
R12: 330; 0207/7
R14: 1k; B25P
T1, T2, T3, T4, T5, T6, T7, T8, T9, T10: 2SC1815; TO92-ECB

Connections:
GND: C2.-, C8.-, C9.+, C10.2, C11.1, IC1.3 (+IN), J1.2 (G), JP1.2, JP2.1, JP2.2, JP4.2, JP5.2, JP6.2, JP7.2, JP9.2, JP10.2, JP11.2, LED2.A, R8.1, R11.1, R17.1
ICTRL: JP8.2, T5.E, T10.E
ICTRL_EXT: JP7.1, JP8.1
ICTRL_JFET: JP8.3, R15.2
unnamed: LED1.K (C), R17.2
unnamed: C3.1, R9.2, T1.E, T2.C
unnamed: C3.2, R10.2, T6.E, T7.C
unnamed: C4.1, T2.E, T3.C
unnamed: C4.2, T7.E, T8.C
unnamed: C5.1, T3.E, T4.C
unnamed: C5.2, T8.E, T9.C
unnamed: C6.1, T4.E, T5.C
unnamed: C6.2, T9.E, T10.C
unnamed: J1.1 (D), R15.1
unnamed: R6.1, R7.2, T4.B, T9.B
unnamed: R5.1, R6.2, T3.B, T8.B
unnamed: R4.1, R5.2, T2.B, T7.B
unnamed: C1.+, R1.2
unnamed: R12.2, R14.A
unnamed: IC1.1 (OUT), IC1.2 (-IN)
unnamed: IC1.6 (-IN), R9.1, R13.1
unnamed: IC1.5 (+IN), R10.1, R11.2
unnamed: J1.3 (S), R16.2
unnamed: C7.-, IC1.7 (OUT), JP4.1, JP10.1, R13.2
unnamed: R14.S, T10.B
unnamed: C7.+, JP3.1
unnamed: JP3.2, R14.E
unnamed: C2.+, R2.1, R7.1, R8.2, R12.1
unnamed: JP6.1, R16.1
unnamed: C1.-, JP1.1, JP9.1
unnamed: R1.1, R2.2, T5.B
unnamed: LED2.K (C), R18.2
unnamed: R3.1, R4.2, T1.B, T6.B
V+: C8.+, C10.1, IC1.8 (V+), JP5.1, JP11.1, LED1.A, R3.2, T1.C, T6.C
V-: C9.-, C11.2, IC1.4 (V-), JP5.3, JP11.3, R18.1

Notes on the sheet:
R9/R10はPinSocketで実装
R1はPinSocketで実装
R3はPinSocketで実装
C7はPinSocketで実装
R16はPinSocketで実装
C3～C6はPinSocketで実装
R8はPinSocketで実装

Board: 2 copper layers, 94.0 x 71.1 mm, 54 parts (0 on the bottom side), 35 nets.

## Commit log

2018-06-17 Update: eagle files
2018-06-18 Update eagle files
2018-06-23 TLF01テスト表
2018-06-23 Update eagle board design
2018-07-07 AntiLog-MM基板設計
2018-08-28 Update: AntilogMM
2019-04-16 Add: Antilog_NPNO
2019-04-17 Add: Antilog_NPNO board design
2019-04-17 Update: Antilog-NPNO board Design
2019-04-27 Add:テスト表
2019-05-03 Add: eagle files (TLF01_toz)
2019-05-04 Update: TLF01_toz
2019-06-01 TLF01故障検査
2019-06-16 Add:TLF01_tozテスト表_20190612.xlsx
2020-10-12 Ad:d Analog Discovery 2

Notices in the files:
parts and their libraries:
con-jst-eh: Copyright (C) 2016, Bob Starr
